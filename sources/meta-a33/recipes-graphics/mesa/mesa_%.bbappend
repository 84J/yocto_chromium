PACKAGECONFIG:append:rk3566 = " kmsro panfrost"
PACKAGECONFIG:append:rk3568 = " kmsro panfrost"
