PACKAGECONFIG:append = "xvfb"

