#SRC_URI:append = " file://cm3-lvds.scc"
